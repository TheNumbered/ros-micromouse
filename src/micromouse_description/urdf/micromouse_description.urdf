Commit message: Described robot with 2 wheels

File: src/micromouse_description/urdf/micromouse_description.urdf (robot description, URDF)
Before this commit: robot micromouse, 3 links, 2 joints
Links:
- link base_link: geometry visual cylinder length=${base_height} radius=${base_width/2}
